File: LeaderSOM.kicad_sch (KiCad schematic)
At the start: 8 parts, among them J1 52465-2470, J2 52465-2470

Commit message: fixed LSOM symbol
Connections:
- net UART1_RX renamed USART1_RX
- net UART1_TX renamed USART1_TX
Other:
- note added: "Changelog: - Changed MCU to STM32G473RET6 - Changed most SOM connector pins slightly - Replaced redunant GND/GNDA pins with more data pins - Added extra functionality to some pins - Added extra SPI, I2C, UART - Removed I2C pullups - Change pp values to be 24V - Swap out power stuff to match PSOM - 24v - 5v buck - 5v power mux - overvoltage/current values - 5v - 3v LDO - Connect IMON to MCU - Reca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"
- note removed: "Changelog: - Changed MCU to STM32G473RET6 - Changed most SOM connector pins slightly - Replaced redunant GND/GNDA pins with more data pins - Added extra functionality to some pins - Change pp values to be 24V - Swap out power stuff to match PSOM - 24v - 5v buck - 5v power mux - overvoltage/current values - 5v - 3v LDO - Connect IMON to MCU - Changed a couple circuits to look better - Replaced sev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"
Changed lines of the file:
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@@
 		)
 	)
-	(text "Changelog:\n- Changed MCU to STM32G473RET6\n- Changed most SOM connector pins slightly\n	- Replaced redunant GND/GNDA pins with more data pins\n	- Added extra functionality to some pins\n- Change pp values to be 24V\n- Swap out power stuff to match PSOM\n	- 24v - 5v buck\n	- 5v power mux\n	- overvoltage/current values\n	- 5v - 3v LDO\n	- Connect IMON to MCU\n- Changed a couple circuits to look better\n- Replaced seven segment with addressable leds (easier, less space)\n- Working on updating ICs to KiCad-Sharepoint from UTSVIT-Kicadlibaries\n- Removed extra general purpose button\n- Bootloader switch and OR gate\n\n\nTODO: \nmake mounting holes plated\nadd spi2 by swapping can1"
+	(text "Changelog:\n- Changed MCU to STM32G473RET6\n- Changed most SOM connector pins slightly\n	- Replaced redunant GND/GNDA pins with more data pins\n	- Added extra functionality to some pins\n	- Added extra SPI, I2C, UART\n	- Removed I2C pullups\n- Change pp values to be 24V\n- Swap out power stuff to match PSOM\n	- 24v - 5v buck\n	- 5v power mux\n	- overvoltage/current values\n	- 5v - 3v LDO\n	- Connect IMON to MCU\n	- Recalculated math\n- Changed a couple circuits to look better\n- Replaced seven segment with addressable leds (easier, less space)\n- Updated ICs to KiCad-Sharepoint from UTSVIT-Kicadlibaries\n- Fixed/added symbols and footprints for several components\n- Removed extra general purpose button\n- Bootloader switch and OR gate\n"
 		(exclude_from_sim no)
 		(at 15.24 149.225 0)
@@
 		)
 	)
-	(label "UART1_TX"
+	(label "USART1_TX"
 		(at 182.88 96.52 0)
 		(effects
@@
 		)
 	)
-	(label "UART1_RX"
+	(label "USART1_RX"
 		(at 182.88 93.98 0)
 		(effects
@@
 		)
 	)
-	(label "UART1_TX"
+	(label "USART1_TX"
 		(at 163.83 119.38 180)
 		(effects
@@
 		)
 	)
-	(label "UART1_RX"
+	(label "USART1_RX"
 		(at 163.83 116.84 180)
 		(effects
