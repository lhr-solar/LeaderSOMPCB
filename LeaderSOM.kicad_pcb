# Repository lhr-solar/LeaderSOMPCB (continued)

## KiCad design LeaderSOM.kicad_pcb (continued)

Schematic: Power_Protection.kicad_sch

Parts:
24V2: TestPoint; TestPoint_Pad_1.0x1.0mm
C42, C45: 10uF; C_0805_2012Metric; Mouser Part Number GRM21BR61H106KE43K
C43, C46: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASU168SB5105KTNA01
C44: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASH168SB7104KTNA01
D17: SD12_SOD323; D_SOD-323; Mouser Part Number 771-PESD15VL1BA-T/R
GND1: TestPoint; TestPoint_Pad_1.0x1.0mm
IC3: LM76202QPWPRQ1; Mouser Part Number 595-LM76202QPWPRQ1
R24: 45.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060345K3FKEAHP
R25: 590; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603590RFKEA
R26: 2.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW06032K10FKEA
R27: 402k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603402KFKEAC
R29: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R30: 8K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R31: 19k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+24V: 24V2.1, C45.1, C46.1, IC3.15 (OUT_1), IC3.16 (OUT_2), R29.1; also elsewhere on the board
/24V_Ext: C42.1, C43.1, D17.1 (A1), IC3.1 (IN_1), IC3.2 (IN_2), R24.1; also elsewhere on the board
/Power_Distribution/FAULT: IC3.14 (~FLT), R29.2; also elsewhere on the board
/Power_Distribution/Power Protection/IMON: IC3.10 (IMON), R31.1
/Power_Distribution/Power Protection/MODE: IC3.6 (MODE), R27.1
/Power_Distribution/Power Protection/OVP: IC3.5 (OVP), R25.2, R26.1
/Power_Distribution/Power Protection/RTN: C44.2, IC3.8 (RTN), IC3.17 (EP), R26.2, R27.2, R30.2, R31.2
/Power_Distribution/Power Protection/SHDN: IC3.7 (~SHDN)
/Power_Distribution/Power Protection/UVLO: IC3.3 (UVLO), R24.2, R25.1
unnamed: C44.1, IC3.12 (DVDT)
unnamed: IC3.11 (ILIM), R30.1

Notes on the sheet:
20.88 ms ramp time
Functional Mode Selection
Set to circuit breaker (latchoff) Use 0 ohm resistor for auto-retry (540ms)
Vin protection
ILim(A) = 12/R(k) 1.5A = 12/8kΩ
Overcurrent Protection
Got rid of current monitoring for an onboard led just leaving it here in case
Under/Overvoltage Protection
RTN!=GND Conecting GND to RTN turns off RPP!
OVP set to 27v for buck max voltage of 28v

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
Board: 4 copper layers, 58.0 x 43.0 mm, 142 parts (12 on the bottom side), 109 nets.

Other parts of the board:
C4, C6: 4.7uF; C_0805_2012Metric
C5, C7: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
R6: 22.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 47.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 49.9; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2: CP2102N-Axx-xQFN24; CP2102N-A02-GQFN24

Their connections:
/MCU/USART3_RX/TIM8_CH2N: U2.21 (TXD); also elsewhere on the board
/MCU/USART3_TX/TIM8_CH1N: U2.20 (RXD); also elsewhere on the board
/USB/D+: U2.3 (D+); also elsewhere on the board
/USB/D-: U2.4 (D-); also elsewhere on the board
unnamed: R6.1, R7.1, U2.8 (VBUS)
unnamed: R8.2, U2.9 (~RST)
VBUS: R6.2; also elsewhere on the board

File jlcpcb/production_files/BOM-LeaderSOM.csv:

Comment,Designator,Footprint,LCSC,Quantity
0.1uF,"C1,C11,C12,C19,C23,C24,C25,C26,C27,C28,C29,C30,C32,C35,C36,C37,C38,C39,C40,C41,C44,C5,C7,C8",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C14663,24
10k,"R1,R12,R17,R22,R23,R29,R33,R9",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25804,8
10nF,C16,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C57112,1
10uF,"C10,C13,C14,C20,C21,C22,C3,C42,C45",C_0805_2012Metric_Pad1.18x1.45mm_HandSolder,C440198,9
120,"R10,R19,R2,R35",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22787,4
16k,R15,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C137788,1
19k,R31,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C22893,1
1k,R8,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C21190,1
1uF,"C15,C18,C2,C43,C46,C9",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C15849,6
2.1k,R26,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C2960801,1
2.2k,"R11,R3",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C4190,2
22.1k,R6,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C31850,1
24V,D4,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,1
26p,"C31,C33",C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C92670,2
3.3nF,C17,C_0603_1608Metric_Pad1.08x0.95mm_HandSolder,C107088,1
332,R14,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C103549,1
3V3,"D21,D5",LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,2
4.3k,"R18,R20",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C2907165,2
4.7uF,C34,C_0805_2012Metric,C106218,1
4.7uF,"C4,C6",C_0805_2012Metric,C98192,2
402k,R27,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C2960796,1
45.3k,R24,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C2933224,1
47.5k,R7,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C25819,1
49.9,R13,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C849792,1
5.1k,"R4,R5",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23186,2
590,R25,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C23084,1
5V,D7,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,1
74AHC1G32,U8,SOT-23-5,C7470,1
768,"R21,R28,R34",R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C5204007,3
8K,R30,R_0603_1608Metric_Pad0.98x0.95mm_HandSolder,C2960681,1
8M,Y1,Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm,C144380,1
BUCK,D20,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,1
CDSOT23-T24CAN,"U1,U3",CDSOT23-T24CAN,C2959841,2
CP2102N-Axx-xQFN24,U2,CP2102N-A02-GQFN24,C969151,1
D5V0P4UR6SO-7,"CR1,CR2,CR3",D5V0P4UR6SO-7,C531179,3
D_Schottky,D1,D_SOD-123,C82544,1
D_TVS,D16,D_SOD-323,C207246,1
FerriteBead,"FB1,FB2",L_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C14709,2
LED,"CC_FLT1,IC_FLT1",LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,2
LT1963AEST-3.3#TRPBF,U4,SOT-223-3_TabPin2,C459918,1
MBR230S1F,D3,D_SOD-123F,C151335,1
Micro_SD_Card_Det,J4,microSD_HC_Hirose_DM3AT-SF-PEJM5,C114218,1
PFLT,D6,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,1
SD12_SOD323,D17,D_SOD-323,C207246,1
SP0503BAHT,D2,SOT-143,C7074,1
STM32G473RETx,U7,LQFP-64_10x10mm_P0.5mm,C730120,1
TPS2115ADRBR,U5,SON65P300X300X100-9N,C140321,1
TPS5405DR,U6,TPS5405DR,C488409,1
USB,D19,LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder,C7371904,1
USB_C_Receptacle_USB2.0_16P,J3,USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal,C393939,1
WS2812B-2020,"D10,D11,D12,D13,D14,D15,D8,D9",WS2812B-2020,C965555,8
100uH,L1,L_Coilcraft_MSS1246-XXX,,1

## KiCad design PowerMUX/PowerMUX.kicad_pcb

Board: 2 copper layers, 54.2 x 24.1 mm, 39 parts (0 on the bottom side), 19 nets.

Parts:
12V+: 12V+; TestPoint_Plated_Hole_D2.0mm
12V-: 12V-; TestPoint_Plated_Hole_D2.0mm
C1, C2, C3, C5: 100nF; C_0805_2012Metric
C4, C6: 47pF; C_0805_2012Metric
C7: 0.1uf; C_0805_2012Metric
C8: 1uf; C_0805_2012Metric
C9, C10, C12, C14: 0.1uF; C_0805_2012Metric
C11: 10uF; C_0805_2012Metric
C13: 47uF; C_0805_2012Metric
CC1, CC2: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical
D1: SP0503BAHT; SOT-143
GND: TestpointGND; TestPoint_Plated_Hole_D2.0mm
J2: UJ31-CH-G2-SMT-TR; CUI_UJ31-CH-G2-SMT-TR
L2: 3.3uH; L_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R1, R2: 27; R_0805_2012Metric
R3: 4.7k; R_0805_2012Metric
R4, R9: 10k; R_0805_2012Metric
R5: 400; R_0805_2012Metric
R6, R7: 5.1k; R_0805_2012Metric
R8: 73k; R_0805_2012Metric
U1: FT230XS-R; SSOP-16_3.9x4.9mm_P0.635mm
U2: TLV70130DBVR; DBV5-L
U3: TPS2115APW; PW8
U5: TPS562231DRLR; SOT-563
[Tx, Rx]: Conn_01x02_Pin; PinSocket_1x02_P2.54mm_Vertical
[Vbus, 5V]: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
[Vbus, D+, D-, GND]: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
mux: Conn_01x01_Pin; PinHeader_1x01_P2.54mm_Vertical

Connections:
5Vmux: C7.1, C14.1, U2.3 (IN), U3.7 (OUT), mux.1
5v: C9.1, C13.1, L2.2, R8.1, U3.8 (IN1), [Vbus, 5V].2
+3.3V: C1.1, C2.1, C3.1, C5.1, C8.1, U1.3 (VCCIO), U1.10 (3V3OUT), U1.11 (RESET), U1.12 (VCC), U2.1 (OUT)
/BST: C12.1, U5.4 (BST)
/SW: C12.2, L2.1, U5.2 (SW)
CC1: CC1.1, J2.A5 (CC1), R6.1
CC2: CC2.1, J2.B5 (CC2), R7.1
D+: C6.1, D1.3 (K), J2.A6 (DP1), R1.2, [Vbus, D+, D-, GND].3
D-: C4.1, D1.4 (K), J2.A7 (DN1), R2.2, [Vbus, D+, D-, GND].2
GND: 12V-.1, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C13.2, C14.2, D1.1 (A), GND.1, J2.A1 (GND), J2.A12 (GND__1), J2.B1 (GND__2), J2.B12 (GND__3), J2.SH1 (SHIELD), J2.SH2 (SHIELD__1), J2.SH3 (SHIELD__2), J2.SH4 (SHIELD__3), R4.2, R5.2, R6.2, R7.2, R9.2, U1.5 (GND), U1.13 (AGND), U2.2 (GND), U3.3 (D1), U3.5 (GND), U5.3 (GND), [Vbus, D+, D-, GND].1
unnamed: U1.4 (RXD), [Tx, Rx].1
unnamed: U1.1 (TXD), [Tx, Rx].2
unnamed: R3.2, R4.1, U1.16 (CBUS3)
unnamed: R2.1, U1.9 (USBDM)
unnamed: R1.1, U1.8 (USBDP)
unnamed: R5.1, U3.4 (ILIM)
unnamed: 12V+.1, C11.1, U5.1 (VIN), U5.5 (EN)
unnamed: R8.2, R9.1, U5.6 (FB)
vbus: C10.1, D1.2 (K), J2.A4 (VBUS), R3.1, U3.6 (IN2), [Vbus, 5V].1, [Vbus, D+, D-, GND].4

File PowerMUX/PowerMUX_BOM.xlsx:

Id | Designator | Footprint | Quantity | Designation | Supplier and ref | Column1 | _1
1 | [Vbus, D+, D-, GND] | PinHeader_1x04_P2.54mm_Vertical | 1 | Conn_01x04_Pin
2 | [Tx, Rx] | PinSocket_1x02_P2.54mm_Vertical | 1 | Conn_01x02_Pin
3 | CC2,CC1,mux | PinHeader_1x01_P2.54mm_Vertical | 3 | Conn_01x01_Pin
4 | [Vbus, 5V] | PinHeader_1x02_P2.54mm_Vertical | 1 | Conn_01x02_Pin
5 | R5 | R_0805_2012Metric | 1 | 400
6 | U3 | PW8 | 1 | TPS2115APW
7 | C6,C4 | C_0805_2012Metric | 2 | 47pF
8 | R8 | R_0805_2012Metric | 1 | 73k
9 | R4,R9 | R_0805_2012Metric | 2 | 10k
10 | GND | TestPoint_Plated_Hole_D2.0mm | 1 | TestpointGND
11 | U1 | SSOP-16_3.9x4.9mm_P0.635mm | 1 | FT230XS-R
12 | U5 | SOT-563 | 1 | TPS562231DRLR
13 | J2 | CUI_UJ31-CH-G2-SMT-TR | 1 | UJ31-CH-G2-SMT-TR
14 | C3,C2,C5,C1 | C_0805_2012Metric | 4 | 100nF
15 | C10,C14,C12,C9 | C_0805_2012Metric | 4 | 0.1uF
16 | D1 | SOT-143 | 1 | SP0503BAHT
17 | C7 | C_0805_2012Metric | 1 | 0.1uf
18 | C11 | C_0805_2012Metric | 1 | 10uF
19 | 12V- | TestPoint_Plated_Hole_D2.0mm | 1 | 12V-
20 | U2 | DBV5-L | 1 | TLV70130DBVR
21 | R1,R2 | R_0805_2012Metric | 2 | 27
22 | R3 | R_0805_2012Metric | 1 | 4.7k
23 | R6,R7 | R_0805_2012Metric | 2 | 5.1k
24 | 12V+ | TestPoint_Plated_Hole_D2.0mm | 1 | 12V+
25 | L2 | L_0805_2012Metric_Pad1.15x1.40mm_HandSolder | 1 | 3.3uH
26 | C13 | C_0805_2012Metric | 1 | 47uF
27 | C8 | C_0805_2012Metric | 1 | 1uf

## Code that names these connections

File LSOM.ioc (part):

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Mcu.Name=STM32G473R(B-C-E)Tx
Mcu.Package=LQFP64
Mcu.UserName=STM32G473RETx
PA0.Mode=IN1-Single-Ended
PA0.Signal=ADC1_IN1
PA1.Mode=IN2-Single-Ended
PA1.Signal=ADC1_IN2
PA10.Signal=GPIO_Output
PA11.Mode=FDCAN_Activate
PA11.Signal=FDCAN1_RX
PA12.Mode=FDCAN_Activate
PA12.Signal=FDCAN1_TX
PA13.Mode=Serial_Wire
PA13.Signal=SYS_JTMS-SWDIO
PA14.Mode=Serial_Wire
PA14.Signal=SYS_JTCK-SWCLK
PA15.Mode=FDCAN_Activate
PA15.Signal=FDCAN3_TX
PA2.Mode=IN3-Single-Ended
PA2.Signal=ADC1_IN3
PA3.Mode=IN4-Single-Ended
PA3.Signal=ADC1_IN4
PA4.Mode=NSS_Signal_Hard_Output
PA4.Signal=SPI1_NSS
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.Mode=Full_Duplex_Master
PA6.Signal=SPI1_MISO
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Mode=FDCAN_Activate
PA8.Signal=FDCAN3_RX
PA9.Mode=IN2-Single-Ended
PA9.Signal=ADC5_IN2
PB0.Mode=IN15-Single-Ended
PB0.Signal=ADC1_IN15
PB1.Mode=IN12-Single-Ended
PB1.Signal=ADC1_IN12
PB10.Mode=Asynchronous
PB10.Signal=USART3_TX
PB11.Mode=Asynchronous
PB11.Signal=USART3_RX
PB12.Mode=NSS_Signal_Hard_Output
PB12.Signal=SPI2_NSS
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB2.Mode=IN12-Single-Ended
PB2.Signal=ADC2_IN12
PB3.Mode=Full_Duplex_Master
PB3.Signal=SPI3_SCK
PB4.Mode=Full_Duplex_Master
PB4.Signal=SPI3_MISO
PB5.Mode=Full_Duplex_Master
PB5.Signal=SPI3_MOSI
PB6.Signal=GPIO_Output
PB7.Signal=GPIO_Input
PB8-BOOT0.Signal=GPIO_Input
PB9.Signal=GPIO_Output
PC0.Mode=IN6-Single-Ended
PC0.Signal=ADC1_IN6
PC1.Mode=IN7-Single-Ended
PC1.Signal=ADC1_IN7
PC10.Mode=Asynchronous
PC10.Signal=UART4_TX
PC11.Mode=Asynchronous
PC11.Signal=UART4_RX
PC12.Mode=Asynchronous
PC12.Signal=UART5_TX
PC2.Mode=IN8-Single-Ended
PC2.Signal=ADC1_IN8
PC3.Mode=IN9-Single-Ended
PC3.Signal=ADC1_IN9
PC4.Mode=Asynchronous
PC4.Signal=USART1_TX
PC5.Mode=Asynchronous
PC5.Signal=USART1_RX
PC6.Mode=I2C
PC6.Signal=I2C4_SCL
PC7.Mode=I2C
PC7.Signal=I2C4_SDA
PC8.Mode=I2C
PC8.Signal=I2C3_SCL
PC9.Mode=I2C
PC9.Signal=I2C3_SDA
PD2.Mode=Asynchronous
PD2.Signal=UART5_RX
PF0-OSC_IN.Mode=HSE-External-Oscillator
PF0-OSC_IN.Signal=RCC_OSC_IN
PF1-OSC_OUT.Mode=HSE-External-Oscillator
PF1-OSC_OUT.Signal=RCC_OSC_OUT
PG10-NRST.Signal=GPIO_Input
RCC.HSE_VALUE=8000000
RCC.SYSCLKFreq_VALUE=16000000
board=custom

## Commit log

2023-09-23 Updated footprint libraries
2023-09-23 Added subsheets
2023-09-30 Updated sheets with copies from other boards
2023-10-05 Updated UART
2023-10-06 Updated pin assignments
2023-10-07 Updated pinouts and added protection circuitry for signals
2023-10-14 Updated power distribution design
2023-10-21 Updated power filtering
2023-10-21 Finished power distribution
2023-10-28 Updated CAN circuitry and used new power protection PMOS
2023-10-28 Finished CAN circuitry
2023-10-28 Fixed CAN jumper
2023-10-30 changed BJT and PMOSFET symbols to standard schematic symbols
2023-10-30 Added power distribution ferrite bead
2023-10-30 Updated datasheets
2023-11-04 Updated power dist and CAN circuitry
2023-11-05 Updated symbols
2023-11-07 ahahaha ahehehe ahohohoho
2023-11-07 f is for friends that do stuff together
2023-11-08 hi lakshay
2023-11-08 u is for u n me
2023-11-08 n is for anywhere and anytime at all
2023-11-09 fuck
2023-11-09 unfuck
2023-11-09 All happy families are alike; each unhappy family is unhappy in its own way.
2023-11-11 updated 12V/5V non-isolated coverter RVAR output-setting resistors to SMD options
2023-11-11 added 3D files and placed properly for 3D view, and added my name on rear silkscreen
2023-11-11 oops didn't save and close before pushing the previous one
2023-11-11 forgot to save readme as well -.-
2023-11-12 changed 12V/5V DC/DC output setting resistors to a generic 1K and 0 Ohm pair, updated LED display to proper model
2023-11-20 gonna order this
2023-11-21 gerbers
2023-11-21 V1.0 (#1) ( no bom )
    * Added subsheets
    * Updated sheets with copies from other boards
    * Updated UART
    * Updated pin assignments
    * Updated pinouts and added protection circuitry for signals
    * Updated power distribution design
2023-12-02 Update images and ReadME
2023-12-02 Fixed ReadME problems
2023-12-02 Added CAN doc to the ReadME
2024-01-20 -Changed C1 TMK212BBJ106MGHT to C0805C106M3PAC7210 because C0805 is on the standardized components and TMK2 is NRND. -Changed C5 & C6 0805YC106KAT2A to C0805C105K5PACTU because C0805 is on the standa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
2024-01-20 added temp file
2024-04-27 fix power dist, update to kicad 8
2024-10-07 Updated schem for redesign
2024-10-14 fix lakshay things
2024-11-16 laid things out but still need to fix things :(
2024-11-18 Cleared up a bunch of constraints violations
2024-11-20 changed cap on osc
2024-12-17 fixed can stuff
2024-12-17 updated symbol and footprint for lsom
2025-01-14 gerbed
2025-01-15 updated pcb
2025-01-15 updated schematic
2025-01-18 power negotiation fix
2025-01-18 UTSVT-Kicad libraries submodule error fixed
2025-01-18 changed old THT buck converter to SMD buck converter from LSOM
2025-01-18 added testpoints
2025-01-18 removed duplicate powerMUXpcb directory
2025-01-29 finished PCB layout
2025-02-01 fix trace width ts ong
2025-02-01 fix traces fr on god
2025-02-01 commit messages are so boring
2025-02-01 buck SW inductor closer to pad, USBc clearance
2025-02-01 added BOM CSV and Excel
2025-02-01 added gerbers
2025-02-17 added header
2025-04-13 hi again lakshay
2025-09-06 i fucked up my ssh keys so im readding the submodules
2025-09-06 kicad sharepoint
2025-09-06 starting redesign
2025-09-13 MCU pins, PSON power distribution, KiCad-Sharepoint, and 7 seg
2025-09-13 net class fixes and ERC
2025-09-13 workday for review
2025-09-15 i did not pay attention in 316
2025-09-16 buses
2025-09-17 mcu sheet
2025-09-18 macbook hater
2025-09-19 review council
2025-09-20 review council stuff
2025-09-20 just updating symbols
2025-09-20 crazy? i used to be crazy
2025-09-21 workday
2025-09-23 power layout
2025-09-23 late night premonitions of disaster
2025-09-23 impending doom is approaching
2025-09-23 routing nightmare
2025-09-24 gm meeting sucked cuz it was in belmont
2025-09-24 redid the traces
2025-09-25 ripping my hair out
2025-09-25 nuke
2025-09-25 classwork
2025-09-25 speedrun
2025-09-26 e leads and civ 6
2025-09-27 6:21:27 split
2025-09-27 workday DRC passed in 11:09:02
2025-09-27 stitching vias
2025-09-28 lsom symbol fix
2025-10-04 lock in
2025-10-04 LSOM ioc file
2025-10-04 16:14:11
2025-10-08 ravi's reviews
2025-10-10 tweaking
2025-10-10 fixed LSOM symbol
2025-10-11 some stuff i forgot
2025-10-11 removed speedrun files
2025-10-11 changing IOC file to only display the internal pins
2025-10-11 lakshay changes and ioc file was changed
2025-10-11 ahahahahsaofiwqihfwqof
2025-10-11 Ravi's chinese part numbers
2025-10-11 JLCPCB BOM and gerbers
2025-11-19 testing
2025-12-01 soldering stuff
2025-12-04 fuckery
2025-12-06 revB for assembly stuff
2025-12-06 teardrops
2025-12-08 JLCPCB BOM/CPL/Gerbers
2026-01-18 the emptiness machine - linkin park
2026-01-20 stuff
2026-01-30 revc start
2026-02-04 updated pins
2026-03-12 qol changes
2026-03-14 layout
2026-03-16 small p/n changes
2026-04-21 some changes maybe, mostly just checking that the brand is pushed
2026-04-27 comp spares with fixed ldo diode
2026-05-17 added revb.3 changelog
