# Repository lhr-solar/LeaderSOMPCB

File README.md:

# LeaderSOM
Author: Pratyush Patra and Jacob Pustilnik (and Tianda Huang)

This board is the Leader System-On-Module (SOM), a multifunction board with an STM32 MCU that is adaptible to the applications of each subsystem. The hardware and software on this board are responsible
for the processing, communication, and data collection tasks required for the car's subsystems.

## BOM
[**Interactive BOM (Must download and open in browser)**](bom/ibom.html)

[**Mouser Cart**]
https://www.mouser.com/ProjectManager/ProjectDetail.aspx?AccessID=f049c28c03

## Connectors
| # | Name | Type | Ideal Voltage | Notes |
| - | - | - | - | - |

## PCB

## Schematic

## Additional Notes

## Current Board Concerns(8.26.2023)

## KiCad design LeaderSOM.kicad_pcb

Parts:
H1, H2, H3, H4: M.3; MountingHole_3.2mm_M3_Pad_TopBottom; not fitted
J1, J2: 52465-2470; 524652470; Mouser Part Number 538-52465-2470
LOGO1: Dr. Hallock; Hallock_Image_Tiny; not fitted
LOGO2: LHRs; LHRs_LOGO; not fitted
TP1: TP_AddressableLED; TestPoint_Pad_1.0x1.0mm

Connections:
+3V3A: J2.13; also elsewhere on the board
/24V_Ext: J1.21, J1.22, J1.23, J1.24; also elsewhere on the board
/AddressableLED: TP1.1; also elsewhere on the board
/MCU/ADC1_IN1/TIM2_CH1/COMP1_OUT: J2.19; also elsewhere on the board
/MCU/ADC1_IN2/TIM2_CH2/COMP1_INP: J2.17; also elsewhere on the board
/MCU/ADC1_IN3/TIM2_CH3/COMP2_INM: J2.15; also elsewhere on the board
/MCU/ADC1_IN6/TIM1_CH1/COMP3_INM: J2.23; also elsewhere on the board
/MCU/ADC1_IN7/TIM1_CH2/COMP3_INP: J2.16; also elsewhere on the board
/MCU/ADC1_IN8/TIM1_CH3/COMP3_OUT: J2.21; also elsewhere on the board
/MCU/ADC1_IN11/COMP7_INM/FDCAN2_RX: J1.12; also elsewhere on the board
/MCU/ADC1_IN12/TIM1_CH3N/COMP1_INP: J2.7; also elsewhere on the board
/MCU/ADC1_IN15/TIM1_CH2N/COMP4_INP: J2.9; also elsewhere on the board
/MCU/ADC2_IN12/TIM5_CH1/COMP4_INM: J1.10; also elsewhere on the board
/MCU/CarCAN_L: J1.6; also elsewhere on the board
/MCU/I2C3_SCL/TIM3_CH3: J1.11; also elsewhere on the board
/MCU/I2C3_SDA/TIM3_CH4: J1.9; also elsewhere on the board
/MCU/I2C4_SCL/TIM3_CH1: J1.7; also elsewhere on the board
/MCU/I2C4_SDA/TIM3_CH2: J1.5; also elsewhere on the board
/MCU/IntCAN_H: J2.8; also elsewhere on the board
/MCU/IntCAN_L: J2.6; also elsewhere on the board
/MCU/LPUART1_RX/TIM2_CH3/OPAMP3_VINM: J2.12; also elsewhere on the board
/MCU/LPUART1_TX/ADC1_IN14/TIM2_CH4: J2.10; also elsewhere on the board
/MCU/OPAMP5_VINM/ADC1_IN4/TIM2_CH4: J2.11; also elsewhere on the board
/MCU/SPI2_MISO/ADC1_IN5/TIM1_CH2N: J1.14; also elsewhere on the board
/MCU/SPI2_MOSI/ADC2_IN15/TIM1_CH3N: J1.18; also elsewhere on the board
/MCU/SPI2_NSS/TIM4_CH4/COMP2_OUT: J1.16; also elsewhere on the board
/MCU/SPI2_SCK/OPAMP3_VINP/FDCAN2_TX: J1.20; also elsewhere on the board
/MCU/SPI3_MISO/TIM3_CH1/USART2_RX: J2.18; also elsewhere on the board
/MCU/SPI3_MOSI/TIM3_CH2/TIM17_CH1: J2.22; also elsewhere on the board
/MCU/SPI3_NSS/TIM1_CH3/COMP6_OUT: J2.20; also elsewhere on the board
/MCU/SPI3_SCK/TIM2_CH2/USART2_TX: J2.24; also elsewhere on the board
/MCU/UART5_RX: J1.15; also elsewhere on the board
/MCU/UART5_TX/TIM5_CH2: J1.13; also elsewhere on the board
/MCU/USART1_RX: J1.19; also elsewhere on the board
/MCU/USART1_TX: J1.17; also elsewhere on the board
GNDA: J2.14; also elsewhere on the board

Notes on the sheet:
Changelog: RevA: - Changed MCU to STM32G473RET6 - Changed most SOM connector pins slightly - Replaced redunant GND/GNDA pins with more data pins - Added extra functionality to some pins - Added extra SPI, I2C, UART - Removed I2C pullups - Change pp values to be 24V - Swap out power stuff to match P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
SOM Connector

Parts:
3.3V1, 5V1: TestPoint; TestPoint_Pad_1.0x1.0mm
C10, C13, C14, C20, C21, C22: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; Mouser Part Number GRM21BR61H106KE43K
C11, C12, C19: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASH168SB7104KTNA01
C15, C18: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASU168SB5105KTNA01
C16: 10nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MSASH168SB5103KTNA01
C17: 3.3nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number 06035C332K4T2A
D3: MBR230S1F; D_SOD-123F; Mouser Part Number MP01EA06
D4: 24V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
D5: 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
D6: PFLT; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
D7: 5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
D18: D_Schottky; D_SOD-123; Mouser Part Number 1N5819HW-7-F
D19: USB; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
D20: BUCK; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
L1: 100uH; L_Coilcraft_MSS1246-XXX; Mouser Part Number MSS1246-104MLC
R14: 332; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603332RFKEAHP
R15: 16k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060316K0FKEA
R16: ROSC; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R17: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R18, R20: 4.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW06034K30FKTA
R19: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603120RFKEC
R21, R28, R34: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603768RFKEA
U4: LT1963AEST-3.3#TRPBF; SOT-223-3_TabPin2; Mouser Part Number LT1963AEST-3.3#TRPBF
U5: TPS2115ADRBR; SON65P300X300X100-9N; Mouser Part Number TPS2115ADRBR
U6: TPS5405DR; Mouser Part Number TPS5405DR

Connections:
+5V: 5V1.1, C10.1, C18.1, D18.2 (A), R17.1, R21.1, U5.7 (OUT); also elsewhere on the board
+5V_BUCK: C12.1, C20.1, C21.1, C22.1, L1.2, R34.1, U5.8 (IN1), U6.5 (VSENSE)
+24V: C13.1, C15.1, R18.1, R20.1, U6.2 (VIN); also elsewhere on the board
/Power_Distribution/FAULT: D6.1 (K); also elsewhere on the board
/Power_Distribution/ILIM: R14.1, U5.4 (ILIM)
/Power_Distribution/ROSC: R16.1, U6.3 (ROSC)
/Power_Distribution/STAT: D7.1 (K), R17.2, U5.1 (STAT)
unnamed: C17.2, R15.1
unnamed: C19.2, D3.1 (K), L1.1, U6.8 (LX)
unnamed: D4.2 (A), R18.2
unnamed: D5.2 (A), R19.2
unnamed: D6.2 (A), R20.2
unnamed: D7.2 (A), R21.2
unnamed: D18.1 (K), U4.1 (IN)
unnamed: D19.2 (A), R28.2
unnamed: D20.2 (A), R34.2
unnamed: C19.1, U6.1 (BOOT)
unnamed: C17.1, U6.6 (COMP)
unnamed: C16.1, U6.4 (SS)
VBUS: C11.1, R28.1, U5.6 (IN2); also elsewhere on the board

Notes on the sheet:
Max current: 1.5A
Vin: 6.5v to 28v Vout: 4.85v to 5.15v
DNP for 120 kHz switching frequency
Ravi fucking hates math
Indicators
Prioritizes IN1 (Buck)
Cout > 33.8uF -> 30uF For 30uF, ESR < 120mΩ
Fault active low
ILim(A) = 500/R 1.5A = 500/332
Slow start time: (10nF * 0.8v)/2uA = 4ms
5->3.3v LDO
24->5v Buck Converter
5v Power Mux
Ripple current: 487mA (243.5 mA per cap) Ripple voltage: 125mV
L: 73.3uH -> 75uH ΔIl: 0.4887A DC load: 1.5A Peak current: 1.7444A

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASH168SB7104KTNA01
C2: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASU168SB5105KTNA01
CC_Term1: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical; not fitted
IC1: TCAN337DCNR; Mouser Part Number 595-TCAN337DCNR
IC_FLT1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number 604-APTD2012LCGCK
R1: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R2: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603120RFKEC
R3: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW06032K10FKEA
U1: CDSOT23-T24CAN; Mouser Part Number CDSOT23-T24CAN

Connections:
/InternalCAN/ICAN_Fault: IC1.5 (FAULT), R1.2, R3.1
/MCU/FDCAN3_RX: IC1.4 (RXD); also elsewhere on the board
/MCU/FDCAN3_TX: IC1.1 (TXD); also elsewhere on the board
/MCU/IntCAN_H: IC1.7 (CANH), R2.2, U1.1 (CAN_H); also elsewhere on the board
/MCU/IntCAN_L: CC_Term1.2 (B), IC1.6 (CANL), U1.2 (CAN_L); also elsewhere on the board
unnamed: CC_Term1.1 (A), R2.1
unnamed: IC_FLT1.2 (A), R3.2

Notes on the sheet:
CAN Bus Protection
CAN Bus Termination
CAN Transceiver
CAN Bus Protection
Decoupling Caps

Parts:
C23, C24, C25, C26, C27, C28, C29, C30: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASH168SB7104KTNA01
D8, D9, D10, D11, D12, D13, D14, D15: WS2812B-2020; Mouser Part Number WS2812-2020
R32: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+5V: C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, D8.4 (VDD), D9.4 (VDD), D10.4 (VDD), D11.4 (VDD), D12.4 (VDD), D13.4 (VDD), D14.4 (VDD), D15.4 (VDD); also elsewhere on the board
/AddressableLED: D8.3 (DIN), R32.1; also elsewhere on the board
unnamed: D8.1 (DOUT), D9.3 (DIN)
unnamed: D9.1 (DOUT), D10.3 (DIN)
unnamed: D10.1 (DOUT), D11.3 (DIN)
unnamed: D11.1 (DOUT), D12.3 (DIN)
unnamed: D12.1 (DOUT), D13.3 (DIN)
unnamed: D13.1 (DOUT), D14.3 (DIN)
unnamed: D14.1 (DOUT), D15.3 (DIN)

Notes on the sheet:
LEDs

Parts:
CR1: D5V0P4UR6SO-7; Mouser Part Number 621-D5V0P4UR6SO-7
J4: Micro_SD_Card_Det; microSD_HC_Hirose_DM3AT-SF-PEJM5; Mouser Part Number DM3AT-SF-PEJM5
R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R10: 49.9; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number RT0603BRE0750RL

Connections:
/MCU/SPI1_MOSI: CR1.6, J4.3 (CMD); also elsewhere on the board
/MCU/SPI1_NSS: CR1.1, J4.2 (DAT3/CD); also elsewhere on the board
/MCU/SPI1_SCK: CR1.4, J4.5 (CLK); also elsewhere on the board

Parts:
C3: 10uF; C_0805_2012Metric; Mouser Part Number GRM21BR61H106KE43K
D1: D_Schottky; D_SOD-123; Mouser Part Number 1N5819HW-7-F
D2: SP0503BAHT; SOT-143; Mouser Part Number 576-SP0503BAHTG
J3: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal; Mouser Part Number 640-USB4105-GF-A
R4, R5: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW06035K10FKEC

Connections:
/USB/CC1: J3.A5 (CC1), R4.2
/USB/CC2: J3.B5 (CC2), R5.2
/USB/D+: D2.3 (K), J3.A6 (D+), J3.B6 (D+); also elsewhere on the board
/USB/D-: D2.2 (K), J3.A7 (D-), J3.B7 (D-); also elsewhere on the board
/USB/VBUS_IN: D1.2 (A), J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
VBUS: C3.2, D1.1 (K), D2.4 (K); also elsewhere on the board

Notes on the sheet:
USB Protection
USB-C Port
Pulldowns for 5V USB-C PD

Parts:
C8: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASH168SB7104KTNA01
C9: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASU168SB5105KTNA01
CC_FLT1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number 604-APTD2012LCGCK
CC_Term2: Jumper_2_Open; PinHeader_1x02_P2.54mm_Vertical; not fitted
IC2: TCAN337DCNR; Mouser Part Number 595-TCAN337DCNR
R9: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R10: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603120RFKEC
R11: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW06032K10FKEA
U3: CDSOT23-T24CAN; Mouser Part Number CDSOT23-T24CAN

Connections:
/MCU/CarCAN_L: CC_Term2.2 (B), IC2.6 (CANL), U3.2 (CAN_L); also elsewhere on the board
/MCU/FDCAN1_RX: IC2.4 (RXD); also elsewhere on the board
/MCU/FDCAN1_TX: IC2.1 (TXD); also elsewhere on the board
unnamed: CC_FLT1.2 (A), R11.2

Notes on the sheet:
CAN Bus Protection
CAN Bus Termination
CAN Bus Protection
CAN Transceiver
Decoupling Caps

Parts:
C31, C33: 26p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number 0603N270F500CT
C32, C35, C36, C37, C38, C39, C40, C41: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder; Mouser Part Number MLASH168SB7104KTNA01
C34: 4.7uF; C_0805_2012Metric; Mouser Part Number 08055D475KAT4A
CR2, CR3: D5V0P4UR6SO-7; Mouser Part Number 621-D5V0P4UR6SO-7
D16: D_TVS; D_SOD-323; Mouser Part Number 771-PESD15VL1BA-T/R
D21: 3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number XL-1608UBC-06A
FB1, FB2: FerriteBead; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder; Mouser Part Number 704-MFBW1V2012-121-R
R22, R23, R33: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW060310K0FKEI
R35: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; Mouser Part Number CRCW0603120RFKEC
Reset1: Reset; TL3365AF180QG; Mouser Part Number 612-TL3365AF180QG
SW1: SW_SPDT; SW_CJS-1200TA; Mouser Part Number CJS-1200TA
SWD1: SWD; Molex_Nano-Fit_105309-xx04_1x04_P2.50mm_Vertical; Mouser Part Number 105309-1104
U7: STM32G473RETx; LQFP-64_10x10mm_P0.5mm; Mouser Part Number STM32G473RET6
U8: 74AHC1G32; SOT-23-5; Mouser Part Number SN74AHC1G32TDBVRQ1
Y1: 8M; Crystal_SMD_Abracon_ABM3-2Pin_5.0x3.2mm; Mouser Part Number ABM3-8.000MHZ-D2Y-T

Connections:
+3V3A: C32.1, C38.1, C39.1, FB2.2, U7.28 (VREF+), U7.29 (VDDA); also elsewhere on the board
/AddressableLED: U7.59 (PB6); also elsewhere on the board
/MCU/ADC1_IN1/TIM2_CH1/COMP1_OUT: U7.12 (PA0); also elsewhere on the board
/MCU/ADC1_IN2/TIM2_CH2/COMP1_INP: U7.13 (PA1); also elsewhere on the board
/MCU/ADC1_IN3/TIM2_CH3/COMP2_INM: U7.14 (PA2); also elsewhere on the board
/MCU/ADC1_IN6/TIM1_CH1/COMP3_INM: U7.8 (PC0); also elsewhere on the board
/MCU/ADC1_IN7/TIM1_CH2/COMP3_INP: U7.9 (PC1); also elsewhere on the board
/MCU/ADC1_IN8/TIM1_CH3/COMP3_OUT: U7.10 (PC2); also elsewhere on the board
/MCU/ADC1_IN11/COMP7_INM/FDCAN2_RX: U7.34 (PB12); also elsewhere on the board
/MCU/ADC1_IN12/TIM1_CH3N/COMP1_INP: U7.25 (PB1); also elsewhere on the board
/MCU/ADC1_IN15/TIM1_CH2N/COMP4_INP: U7.24 (PB0); also elsewhere on the board
/MCU/ADC2_IN12/TIM5_CH1/COMP4_INM: U7.26 (PB2); also elsewhere on the board
/MCU/BOOT: D16.2 (A2), R23.2, U7.61 (PB8)
/MCU/BOOT_GPIO: R22.2, U7.60 (PB7), U8.2
/MCU/FDCAN1_RX: U7.45 (PA11); also elsewhere on the board
/MCU/FDCAN1_TX: U7.46 (PA12); also elsewhere on the board
/MCU/FDCAN3_RX: U7.42 (PA8); also elsewhere on the board
/MCU/FDCAN3_TX: U7.51 (PA15); also elsewhere on the board
/MCU/I2C3_SCL/TIM3_CH3: U7.40 (PC8); also elsewhere on the board
/MCU/I2C3_SDA/TIM3_CH4: U7.41 (PC9); also elsewhere on the board
/MCU/I2C4_SCL/TIM3_CH1: U7.38 (PC6); also elsewhere on the board
/MCU/I2C4_SDA/TIM3_CH2: U7.39 (PC7); also elsewhere on the board
/MCU/LPUART1_RX/TIM2_CH3/OPAMP3_VINM: U7.30 (PB10); also elsewhere on the board
/MCU/LPUART1_TX/ADC1_IN14/TIM2_CH4: U7.33 (PB11); also elsewhere on the board
/MCU/NRST: C40.1, R33.1, Reset1.1, U7.7 (PG10)
/MCU/OPAMP5_VINM/ADC1_IN4/TIM2_CH4: U7.17 (PA3); also elsewhere on the board
/MCU/OSC_IN: C33.2, U7.5 (PF0), Y1.2
/MCU/OSC_OUT: C31.1, U7.6 (PF1), Y1.1
/MCU/Onboard_LED: R35.1, U7.11 (PC3)
/MCU/SPI1_MOSI: U7.21 (PA7); also elsewhere on the board
/MCU/SPI1_NSS: U7.18 (PA4); also elsewhere on the board
/MCU/SPI1_SCK: U7.19 (PA5); also elsewhere on the board
/MCU/SPI2_MISO/ADC1_IN5/TIM1_CH2N: CR2.3, U7.36 (PB14); also elsewhere on the board
/MCU/SPI2_MOSI/ADC2_IN15/TIM1_CH3N: CR2.6, U7.37 (PB15); also elsewhere on the board
/MCU/SPI2_NSS/TIM4_CH4/COMP2_OUT: CR2.1, U7.62 (PB9); also elsewhere on the board
/MCU/SPI2_SCK/OPAMP3_VINP/FDCAN2_TX: CR2.4, U7.35 (PB13); also elsewhere on the board
/MCU/SPI3_MISO/TIM3_CH1/USART2_RX: CR3.3, U7.57 (PB4); also elsewhere on the board
/MCU/SPI3_MOSI/TIM3_CH2/TIM17_CH1: CR3.6, U7.58 (PB5); also elsewhere on the board
/MCU/SPI3_NSS/TIM1_CH3/COMP6_OUT: CR3.1, U7.44 (PA10); also elsewhere on the board
/MCU/SPI3_SCK/TIM2_CH2/USART2_TX: CR3.4, U7.56 (PB3); also elsewhere on the board
/MCU/SWCLK: SWD1.2, U7.50 (PA14)
/MCU/SWDIO: SWD1.4, U7.49 (PA13)
/MCU/UART5_RX: U7.55 (PD2); also elsewhere on the board
/MCU/UART5_TX/TIM5_CH2: U7.54 (PC12); also elsewhere on the board
/MCU/USART1_RX: U7.23 (PC5); also elsewhere on the board
/MCU/USART1_TX: U7.22 (PC4); also elsewhere on the board
/MCU/USART3_RX/TIM8_CH2N: U7.53 (PC11); also elsewhere on the board
/MCU/USART3_TX/TIM8_CH1N: U7.52 (PC10); also elsewhere on the board
GNDA: C32.2, C38.2, C39.2, FB1.1, U7.27 (VSSA); also elsewhere on the board
unnamed: D21.2 (A), R35.2
unnamed: R23.1, U8.4
unnamed: SW1.2 (B), U8.1

Notes on the sheet:
Do not use on daughter boards
Internal Connections
Boot Switch
VDDA Bypass Caps
Bypass/Separation
Reset Button
SWD Connector
SPI Protection
VDD Bypass Caps
All Potential Pins
Internal Connections
VDDA Separation
Buttons & Stuff
