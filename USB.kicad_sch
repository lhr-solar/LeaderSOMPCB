File: USB.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Updated UART
Parts:
- added C17: 4.7uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added C18: 0.1uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added D1: SP0503BAHT, Package_TO_SOT_SMD:SOT-143, symbol Dash2-rescue:SP0503BAHT-Power_Protection
- added J3: USB_B_Micro, Connector_USB:USB_Micro-B_Molex-105017-0001, symbol Dashboard-rescue:USB_B_Micro-Connector
- added R5: 22.1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added R6: 47.5k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added R7: 1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added U6: CP2102N-A01-GQFN24, Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm, symbol Interface_USB:CP2102N-A01-GQFN24
Connections:
- new net: R7.2, U6.9 (~{RSTb})
- new net: D1.2 (K), J3.1 (VBUS), R5.2
- new net: D1.3 (K), J3.2 (D-), U6.4 (D-)
- new net: D1.4 (K), J3.3 (D+), U6.3 (D+)
- new net: R5.1, R6.1, U6.8 (VBUS)
- new net +3.3V: C17.1, C18.1, R7.1, U6.5 (VIO), U6.6 (VDD), U6.7 (REGIN)
- new net GND: C17.2, C18.2, D1.1 (A), J3.5 (GND), J3.6 (Shield), R6.2, U6.2 (GND), U6.25 (GND)
- new net UART3_RX: U6.20 (RXD)
- new net UART3_TX: U6.21 (TXD)
- no-connect marks 0 -> 13
Other:
- note added: "From BPS Peripheral SOM"
- note added: "The microcontroller should have Rx connected to UART_TX and Tx connected to UART_RX"

Commit message: Updated pinouts and added protection circuitry for signals
Parts:
- removed C17: 4.7uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed R7: 1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- removed U6: CP2102N-A01-GQFN24, Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm, symbol Interface_USB:CP2102N-A01-GQFN24
- added C19: 100nF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- added R8: 1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
- added U1: CP2102N-A02-GQFN24, Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm, symbol Interface_USB:CP2102N-A01-GQFN24
- C18: value 0.1uF -> 4.7uF; Mouser Part Number 80-C0805C104K3R -> 81-GRM219R6YA475KA3D; P/N (none) -> GRM219R6YA475KA73D
- D1: P/N (none) -> SP0503BAHTG
- R5: P/N (none) -> CRCW080522K1FKEA
- R6: P/N (none) -> CRCW080547K5FKEA
Connections:
- net +3.3V: now also C19.1, R8.1, U1.5 (VIO), U1.6 (VDD), U1.7 (REGIN)
- net GND: now also C19.2, U1.2 (GND), U1.25 (GND)
- net at D1.3 (K), J3.2 (D-): now also U1.4 (D-)
- net at D1.4 (K), J3.3 (D+): now also U1.3 (D+)
- net at R5.1, R6.1: now also U1.8 (VBUS)
- new net: R8.2, U1.9 (~{RSTb})
- new net UART_3RX: U1.20 (RXD)
- new net UART_3TX: U1.21 (TXD)

Commit message: Updated power dist and CAN circuitry
Parts:
- removed D1: SP0503BAHT, Package_TO_SOT_SMD:SOT-143, symbol Dash2-rescue:SP0503BAHT-Power_Protection
- removed J3: USB_B_Micro, Connector_USB:USB_Micro-B_Molex-105017-0001, symbol Dashboard-rescue:USB_B_Micro-Connector
- removed U1: CP2102N-A02-GQFN24, Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm, symbol Interface_USB:CP2102N-A01-GQFN24
- added D1: SP0503BAHT, Package_TO_SOT_SMD:SOT-143, symbol utsvt-chips:SP0503BAHT-Power_Protection
- added J2: USB_B_Micro, Connector_USB:USB_Micro-B_Molex-105017-0001, symbol utsvt-connectors:USB_B_Micro-Connector
- added U3: CP2102N-A02-GQFN24, Package_DFN_QFN:QFN-24-1EP_4x4mm_P0.5mm_EP2.6x2.6mm, symbol utsvt-chips:CP2102N-A01-GQFN24
Connections:
- net +3.3V: now also U3.5 (VIO), U3.6 (VDD), U3.7 (REGIN)
- net GND: now also D1.1 (A), J2.5 (GND), J2.6 (Shield), U3.2 (GND), U3.25 (GND)
- net UART_3RX: now also U3.21 (TXD)
- net UART_3TX: now also U3.20 (RXD)
- net at R5.2: now also D1.2 (K), J2.1 (VBUS)
- net at R5.1, R6.1: now also U3.8 (VBUS)
- net at R8.2: now also U3.9 (~{RSTb})
- new net: D1.3 (K), J2.2 (D-), U3.4 (D-)
- new net: D1.4 (K), J2.3 (D+), U3.3 (D+)

Commit message: a
Connections:
- net UART_3RX renamed UART_RX
- net UART_3TX renamed UART_TX
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (hierarchical_label "UART_3TX" (shape output) (at 181.61 88.265 0) (fields_autoplaced)
+  (hierarchical_label "UART_TX" (shape output) (at 181.61 88.265 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
-  (hierarchical_label "UART_3RX" (shape input) (at 181.61 90.805 0) (fields_autoplaced)
+  (hierarchical_label "UART_RX" (shape input) (at 181.61 90.805 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 177.8 70.485 0)
+    (property "Datasheet" "~" (at 177.8 70.485 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.vishay.com/docs/20035/dcrcwe3.pdf" (at 134.62 113.665 0)
+    (property "Datasheet" "~" (at 134.62 113.665 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.vishay.com/docs/28773/crcwce3.pdf" (at 137.16 75.565 0)
+    (property "Datasheet" "~" (at 137.16 75.565 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.vishay.com/docs/20035/dcrcwe3.pdf" (at 125.73 103.505 0)
+    (property "Datasheet" "~" (at 125.73 103.505 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/ProductDetail/Murata-Electronics/GRM219R6YA475KA73D?qs=eeBpzGFlv%252B%252Bho6epIC%2FPCA%3D%3D" (at 165.1 70.485 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Datasheet" "~" (at 165.1 70.485 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: updated pin assignments
Changed lines of the file:
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@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (hierarchical_label "UART_TX" (shape output) (at 181.61 88.265 0) (fields_autoplaced)
+  (hierarchical_label "UART_TX" (shape input) (at 181.61 88.265 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
-  (hierarchical_label "UART_RX" (shape input) (at 181.61 90.805 0) (fields_autoplaced)
+  (hierarchical_label "UART_RX" (shape output) (at 181.61 90.805 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left))
   )
@@
         (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/94125b35-79a1-41d0-8b6c-f77e699b83b8"
           (reference "R5") (unit 1)
-        )
-      )
-    )
-  )
-  (symbol (lib_id "power:+3.3V") (at 152.4 69.215 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR030" (at 152.4 73.025 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+3.3V" (at 152.781 64.8208 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 152.4 69.215 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 152.4 69.215 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "LeaderSOM"
-        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/5bc03b31-fe77-4b0c-be7c-10fb7ad1c047"
-          (reference "#PWR030") (unit 1)
-        )
-      )
-      (project "Dashboard"
-        (path "/66218487-e316-4467-9eba-79d4626ab24e/00000000-0000-0000-0000-00005f7a9238"
-          (reference "#PWR0105") (unit 1)
-        )
-      )
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/94125b35-79a1-41d0-8b6c-f77e699b83b8"
-          (reference "#PWR08") (unit 1)
         )
       )
@@
     )
   )
+  (symbol (lib_id "power:+3.3V") (at 134.62 93.345 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR025" (at 134.62 97.155 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3.3V" (at 134.62 89.535 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 134.62 93.345 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 134.62 93.345 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "LeaderSOM"
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca"
+          (reference "#PWR025") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/07cef2e6-f2f4-4f04-bcaf-7b98b53ab0fe"
+          (reference "#PWR025") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/5bc03b31-fe77-4b0c-be7c-10fb7ad1c047"
+          (reference "#PWR014") (unit 1)
+        )
+      )
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d"
+          (reference "#PWR02") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "power:GND") (at 154.94 121.285 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
-  (symbol (lib_id "power:+3.3V") (at 134.62 93.345 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "#PWR014" (at 134.62 97.155 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Value" "+3.3V" (at 135.001 88.9508 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "" (at 134.62 93.345 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "" (at 134.62 93.345 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (instances
-      (project "LeaderSOM"
-        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/5bc03b31-fe77-4b0c-be7c-10fb7ad1c047"
-          (reference "#PWR014") (unit 1)
-        )
-      )
-      (project "Dashboard"
-        (path "/66218487-e316-4467-9eba-79d4626ab24e/00000000-0000-0000-0000-00005f7a9238"
-          (reference "#PWR0103") (unit 1)
-        )
-      )
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/94125b35-79a1-41d0-8b6c-f77e699b83b8"
-          (reference "#PWR06") (unit 1)
-        )
-      )
+  (symbol (lib_id "power:+3.3V") (at 152.4 69.215 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no) (fields_autoplaced)
+    (property "Reference" "#PWR025" (at 152.4 73.025 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "+3.3V" (at 152.4 65.405 0)
+      (effects (font (size 1.27 1.27)))
+    )
+    (property "Footprint" "" (at 152.4 69.215 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 152.4 69.215 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "LeaderSOM"
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca"
+          (reference "#PWR025") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/07cef2e6-f2f4-4f04-bcaf-7b98b53ab0fe"
+          (reference "#PWR025") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/5bc03b31-fe77-4b0c-be7c-10fb7ad1c047"
+          (reference "#PWR030") (unit 1)
+        )
+      )
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d"
+          (reference "#PWR02") (unit 1)
+        )
+      )
