File: MCU.kicad_sch (KiCad schematic)
At the start: 24 parts, among them SW1 SW_SPDT, U7 STM32G473RETx, U8 74AHC1G32, Y1 8M

Commit message: changing IOC file to only display the internal pins
Other:
- note added: "All Potential Pins"
- note added: "Do not use on daughter boards"
