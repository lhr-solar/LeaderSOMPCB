File: CarCAN.kicad_sch (KiCad schematic)
At the start: 13 parts, among them J11 CAN_In2, J12 CAN_Out2, U4 ISO1044BD, U5 CDSOT23-T24CAN

Commit message: Updated power dist and CAN circuitry
Parts:
- removed PS1: 1769405141, 1769405141, symbol UTSVT_LeaderSOM:1769405141
- added PS1: 1769405141, 1769405141, symbol utsvt-power-regulators:1769405141
- JP1: value Termination Resistors -> CAN_PWR Jumper
- JP1: value Termination Resistors -> CAN_GND Jumper
Connections:
- net +5V: now also PS1.2 (+VIN)
- net 5V_ISO: now also PS1.5 (+VOUT)
- net GND: now also PS1.1 (-VIN)
- net GND_ISO: now also C6.2, PS1.4 (-VOUT)
- net GND2 renamed -V_CAN2
- net -V_CAN2: no longer C6.2
- net V_CAN_IN renamed +V_CAN2

Commit message: a
Parts:
- removed JP1: CAN_GND Jumper, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Jumper:Jumper_2_Open
- PS1: footprint 1769405141 -> UTSVT_Power:1769405141
Connections:
- net GND_ISO is gone; now on net -V_CAN2: C6.2, PS1.4 (-VOUT)
Other:
- note added: "+5V supply for Car CAN. Only one is required for the entire car. Only one can be enabled at a time in the car. Disable unused supplies with the jumper. 400mA Max"
- note added: "-V_CAN2 != GND -V_CAN2 = CAN GND = GND_ISO_In/Out"
- note removed: "GND1 != GND GND1 = CAN GND = GND_ISO_In/Out"
Changed lines of the file:
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@@
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 199.39 92.71) (xy 201.295 92.71))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 172.72 92.71) (xy 182.245 92.71))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 164.465 133.35) (xy 170.18 133.35))
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 172.72 92.71) (xy 189.23 92.71))
-    (stroke (width 0) (type default))
-  )
   (wire (pts (xy 151.765 95.25) (xy 151.765 107.315))
     (stroke (width 0) (type default))
@@
   (wire (pts (xy 226.06 88.9) (xy 226.06 104.14))
     (stroke (width 0) (type default))
+  )
+  (rectangle (start 215.9 71.755) (end 272.415 109.855)
+    (stroke (width 0) (type default))
+    (fill (type none))
   )
   (text "ISOLATED" (at 111.125 81.28 0)
     (effects (font (size 2.54 2.54) (thickness 0.508) bold) (justify left bottom))
   )
-  (text "GND1 != GND\n\nGND1 = CAN GND = GND_ISO_In/Out" (at 109.22 37.465 0)
+  (text "-V_CAN2 != GND\n\n-V_CAN2 = CAN GND = GND_ISO_In/Out"
+    (at 109.22 37.465 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
   )
   (text "Local (Primary Board) GND" (at 84.455 106.045 0)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (text "+5V supply for Car CAN.\nOnly one is required for the entire car.\nOnly one can be enabled at a time in the car. \nDisable unused supplies with the jumper.\n400mA Max"
+    (at 215.9 70.485 0)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "GND_ISO" (at 229.235 100.965 0) (fields_autoplaced)
+  (label "-V_CAN2" (at 229.235 100.965 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "-V_CAN2" (at 177.8 92.71 0) (fields_autoplaced)
+  (label "-V_CAN2" (at 182.245 92.71 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "GND_ISO" (at 142.875 75.565 0) (fields_autoplaced)
+  (label "-V_CAN2" (at 142.875 75.565 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
     (effects (font (size 1.27 1.27)) (justify right bottom))
   )
-  (label "GND_ISO" (at 201.295 92.71 0) (fields_autoplaced)
-    (effects (font (size 1.27 1.27)) (justify left bottom))
-  )
   (label "5V_ISO" (at 264.16 91.44 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 156.21 88.9 0)
+    (property "Datasheet" "~" (at 156.21 88.9 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/40/AVX_X7RDielectric_777024-1853642.pdf" (at 142.875 70.485 0)
+    (property "Datasheet" "~" (at 142.875 70.485 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_name "CANConnector_1") (lib_id "utsvt-connectors:CANConnector") (at 118.11 137.16 0) (unit 1)
+  (symbol (lib_id "utsvt-connectors:CANConnector") (at 118.11 137.16 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
     (property "Reference" "J11" (at 118.11 127 0)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.vishay.com/docs/20035/dcrcwe3.pdf" (at 141.605 102.87 0)
+    (property "Datasheet" "~" (at 141.605 102.87 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
       (effects (font (size 1.27 1.27)))
     )
-    (property "Footprint" "1769405141" (at 255.905 183.82 0)
+    (property "Footprint" "UTSVT_Power:1769405141" (at 255.905 183.82 0)
       (effects (font (size 1.27 1.27)) (justify left top) hide)
     )
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/87/eaton_mfbw1v2012_high_impedance_multilayer_ferrite-1916871.pdf" (at 135.89 66.675 0)
+    (property "Datasheet" "~" (at 135.89 66.675 0)
       (effects (font (size 1.27 1.27)) hide)
     )
@@
     )
   )
-  (symbol (lib_id "Jumper:Jumper_2_Open") (at 194.31 92.71 0) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "JP1" (at 194.31 86.995 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "CAN_GND Jumper" (at 194.31 88.9 0)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" (at 194.31 92.71 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 194.31 92.71 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (instances
-      (project "LeaderSOM"
-        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/3c3cb7b2-3464-4424-b8df-3064a68eb04d"
-          (reference "JP1") (unit 1)
-        )
-        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/8f4dac5b-9bb8-4793-8ce7-913e39731a3f"
-          (reference "JP4") (unit 1)
-        )
-      )
-      (project "Dashboard"
-        (path "/66218487-e316-4467-9eba-79d4626ab24e/00000000-0000-0000-0000-00005f547b94"
-          (reference "JP2") (unit 1)
-        )
-      )
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
-          (reference "JP2") (unit 1)
-        )
-      )
-    )
-  )
   (symbol (lib_id "Device:C_Small") (at 90.805 93.98 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
       (effects (font (size 1.27 1.27)) hide)
     )
-    (property "Datasheet" "https://www.mouser.com/datasheet/2/212/KEM_C1002_X7R_SMD-1102033.pdf" (at 90.805 93.98 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
+    (property "Datasheet" "~" (at 90.805 93.98 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )

Commit message: 👹
Parts:
- added D2: V_CAN2, LED_SMD:LED_0805_2012Metric, symbol Device:LED
- added R1: 5.1k, Resistor_SMD:R_0805_2012Metric, symbol Device:R
Connections:
- net +V_CAN2: now also R1.1
- net -V_CAN2: now also D2.1 (K)
- new net: D2.2 (A), R1.2
Changed lines of the file:
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@@
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 209.55 121.92) (xy 209.55 127))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 209.55 147.955) (xy 209.55 143.51))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 169.545 108.585) (xy 170.815 108.585))
     (stroke (width 0) (type default))
@@
   )
   (wire (pts (xy 131.445 97.79) (xy 131.445 110.49))
+    (stroke (width 0) (type default))
+  )
+  (wire (pts (xy 209.55 135.89) (xy 209.55 134.62))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
+  (label "+V_CAN2" (at 209.55 121.92 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
+  )
   (label "CAN_H" (at 132.715 138.43 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
+  (label "-V_CAN2" (at 209.55 147.955 180) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify right bottom))
   )
   (label "CAN_L" (at 170.18 140.97 0) (fields_autoplaced)
@@
         (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/1d0c269d-60cf-499b-bfd2-5087981d6678"
           (reference "C6") (unit 1)
+        )
+      )
+    )
+  )
+  (symbol (lib_id "Device:LED") (at 209.55 139.7 90) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "D2" (at 212.5472 138.7348 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Value" "V_CAN2" (at 212.5472 141.0462 90)
+      (effects (font (size 1.27 1.27)) (justify right))
+    )
+    (property "Footprint" "LED_SMD:LED_0805_2012Metric" (at 209.55 139.7 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 209.55 139.7 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Color" "Green" (at 209.55 139.7 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "APTD2012LCGCK" (at 209.55 139.7 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Vf" "1.9V" (at 209.55 139.7 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "If" "2mA" (at 209.55 139.7 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "604-APTD2012LCGCK" (at 209.55 139.7 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "LeaderSOM"
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/07cef2e6-f2f4-4f04-bcaf-7b98b53ab0fe"
+          (reference "D2") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/8c1921d3-7d8b-4937-baba-7ed9d4d1349f"
+          (reference "D5") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/3c3cb7b2-3464-4424-b8df-3064a68eb04d"
+          (reference "D5") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/8f4dac5b-9bb8-4793-8ce7-913e39731a3f"
+          (reference "D6") (unit 1)
+        )
+      )
+      (project "Telemetry-Primary"
+        (path "/7f2a449b-14af-42b3-8d38-5f0f8a5ee7ce/00000000-0000-0000-0000-00005f6cdfd6"
+          (reference "D1") (unit 1)
+        )
+      )
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/40e00f49-8295-4a27-8e00-c31cad3b7d6c"
+          (reference "D10") (unit 1)
+        )
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
+          (reference "D2") (unit 1)
         )
       )
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Device:R") (at 209.55 130.81 0) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "R1" (at 211.328 129.6416 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Value" "5.1k" (at 211.328 131.953 0)
+      (effects (font (size 1.27 1.27)) (justify left))
+    )
+    (property "Footprint" "Resistor_SMD:R_0805_2012Metric" (at 207.772 130.81 90)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "~" (at 209.55 130.81 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "P/N" "Inventory" (at 209.55 130.81 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser Part Number" "Inventory" (at 209.55 130.81 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "LeaderSOM"
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/07cef2e6-f2f4-4f04-bcaf-7b98b53ab0fe"
+          (reference "R1") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/8c1921d3-7d8b-4937-baba-7ed9d4d1349f"
+          (reference "R34") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/3c3cb7b2-3464-4424-b8df-3064a68eb04d"
+          (reference "R34") (unit 1)
+        )
+        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/8f4dac5b-9bb8-4793-8ce7-913e39731a3f"
+          (reference "R37") (unit 1)
+        )
+      )
+      (project "Telemetry-Primary"
+        (path "/7f2a449b-14af-42b3-8d38-5f0f8a5ee7ce/00000000-0000-0000-0000-00005f6cdfd6"
+          (reference "R5") (unit 1)
+        )
+      )
+      (project "BPS-PeripheralSOM"
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/40e00f49-8295-4a27-8e00-c31cad3b7d6c"
+          (reference "R12") (unit 1)
+        )
+        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
+          (reference "R1") (unit 1)
+        )
+      )

Commit message: f is for friends that do stuff together
Parts:
- removed FB1: 5VFB, Inductor_SMD:L_0805_2012Metric, symbol Device:FerriteBead_Small
Connections:
- net 5V_ISO: now also C6.1, JP1.2 (B)
Changed lines of the file:
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@@
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 156.21 85.09) (xy 160.02 85.09))
-    (stroke (width 0) (type default))
-  )
-  (wire (pts (xy 138.43 66.675) (xy 142.875 66.675))
     (stroke (width 0) (type default))
   )
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 156.21 85.09) (xy 175.895 85.09))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 127 135.89) (xy 132.715 135.89))
     (stroke (width 0) (type default))
@@
     (stroke (width 0) (type default))
   )
-  (wire (pts (xy 130.81 66.675) (xy 133.35 66.675))
+  (wire (pts (xy 130.81 66.675) (xy 142.875 66.675))
     (stroke (width 0) (type default))
   )
@@
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
-  (label "+V_CAN2" (at 160.02 85.09 0) (fields_autoplaced)
+  (label "+V_CAN2" (at 175.895 85.09 0) (fields_autoplaced)
     (effects (font (size 1.27 1.27)) (justify left bottom))
   )
@@
         )
       )
-    )
-  )
-  (symbol (lib_id "Device:FerriteBead_Small") (at 135.89 66.675 270) (unit 1)
-    (in_bom yes) (on_board yes) (dnp no)
-    (property "Reference" "FB1" (at 135.255 72.39 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Value" "5VFB" (at 135.255 69.85 90)
-      (effects (font (size 1.27 1.27)))
-    )
-    (property "Footprint" "Inductor_SMD:L_0805_2012Metric" (at 135.89 64.897 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Datasheet" "~" (at 135.89 66.675 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "P/N" "MFBW1V2012-121-R" (at 135.89 66.675 90)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (property "Mouser Part Number" "704-MFBW1V2012-121-R" (at 135.89 66.675 0)
-      (effects (font (size 1.27 1.27)) hide)
-    )
-    (pin "1")
-    (pin "2")
-    (instances
-      (project "LeaderSOM"
-        (path "/192d0c36-944e-4927-949b-263b8c85a7ca/8f4dac5b-9bb8-4793-8ce7-913e39731a3f"
-          (reference "FB1") (unit 1)
-        )
-      )
-      (project "Controls-LightingPCB"
-        (path "/229b82f0-5048-47d6-8bc8-0bcee42eb4bc"
-          (reference "FB1") (unit 1)
-        )
-      )
-      (project "BPS-PeripheralSOM"
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d"
-          (reference "FB2") (unit 1)
-        )
-        (path "/d5ebd247-5a7c-47c2-8aee-beabaef72d6d/60a4ab70-544e-48ed-aa76-f39bfcac39df"
-          (reference "FB2") (unit 1)
-        )
-      )

Commit message: hi lakshay
Parts:
- removed C6: 10uF, Capacitor_SMD:C_0805_2012Metric, symbol Device:C
- removed JP1: CAN_PWR Jumper, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Jumper:Jumper_2_Open
- removed PS1: 1769405141, UTSVT_Power:1769405141, symbol utsvt-power-regulators:1769405141
Other:
- note added: "+V_CAN and -V_CAN must be supplied externally"
- note removed: "+5V supply for Car CAN. Only one is required for the entire car. Only one can be enabled at a time in the car. Disable unused supplies with the jumper. 400mA Max"
